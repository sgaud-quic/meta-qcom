require firmware-qcom-boot-qcs615.inc

SRC_URI[bootbinaries.sha256sum] = "e9552e73ebde1a814fd4452540826d3cf4f25d70a98ab508a7afe860b1fb24a9"
